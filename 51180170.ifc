Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2024-10-10T12:11:14
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20200210_1400(x64) - Exporter 20.2.12.1 - Alternate UI 20.2.12.1
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Oct 10 12:11:14 2024 * Host: DESKTOP-BQGE6H4 * Database: C:\Users\Avocado\AppData\Local\Temp\8f93c90a-c7b8-4513-8acb-ad717d5238bc\9c4665bc-0e0b-4dde-87e2-f9d56951aa7a\ifc * Database version: 5507 * Database creation date: Thu Oct 10 12:11:13 2024 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Oct 10 12:11:13 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Oct 10 12:11:13 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 51180170 Wall coupling for shower hose, G1/2, 51180170:51180170 Wall coupling for shower hose, G1/2:489993
In: Level 1
Type - PredefinedType: FAUCET
Type - Constraints - Default Elevation: 0 mm
Type - Construction - Type: 0
Type - Dimensions - NominalDepth: 60 mm; NominalHeight: 75 mm; NominalWidth: 75 mm
Type - General - Author: BIMStone; BIMObjectName: 51180170; ManufacturerName: HANSA; ManufacturerURL: http://www.hansa.com; NBSDescription: Shower mixers; NBSReference: 45-35-70/335; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_78; Uniclass2015Description: Shower manual water supply sets; Uniclass2015Reference: Pr_40_20_87_78; Version: 1; VersionDate: 20/08/2024
Type - Green Building Properties - EAN Number: 4015474173101; ETIM Class Number: EC011616 Parts for sanitary taps; Sales Package dimensions (LxWxH): 164.0 x 85.0 x 85.0; UNSPSC Class Number: 30181800 Faucet and shower heads, jets and parts and accessories; URL Declaration of Asbestos: http://static.hansa.com/doc/asbestos; URL Declaration of Conformity: http://static.hansa.com/DoC/51180170; URL Declaration Of Performance (DOP): http://static.hansa.com/doc/DoP; URL Declaration of SCIP: http://static.hansa.com/doc/SCIP; URL EcoLabel Declaration: http://static.hansa.com/doc/EcoLabel; URL EU Packaging Declaration: http://static.hansa.com/doc/packaging; URL REACH: http://static.hansa.com/doc/reach
Type - Identity Data - 2D/3D/BIM Files URL: http://static.hansa.com/bim/51180170; 3D View: https://static.hansa.com/3D/51180170; Catalog Drawing URL: http://static.hansa.com/catdrw/51180170; Category B2B: Accessories; Category B2C: Shower solutions; Color variants: 5118017033; Dimension Drawing URL: http://static.hansa.com/dimdrw/51180170; FDV Document URL: http://www.hansa.com/datasheet/51180170/en/fdv; Group: Wall coupling for shower hose; Installation and Maintenance Guide URL: http://static.hansa.com/manual/51180170; Interactive AR View URL: https://static.hansa.com/AR/51180170; Manufacturer: HANSA; Market: International;Germany;Austria;Switzerland;Belgium;Netherlands;France;Czech Republic;Slovakia;Italy;Spain;Portugal; Mobile Product Information URL: http://mpi.hansa.com/51180170; Model: 51180170 Wall coupling for shower hose, G1/2; Name_en: 51180170 Wall coupling for shower hose, G1/2; OmniClass Number: 23.45.55.00; Product Code: 51180170; Product Family: HANSA; Product Image URL: http://static.hansa.com/image/51180170; Product URL: http://static.hansa.com/51180170; Spare-Part Information URL: http://static.hansa.com/sp/51180170; Technical DataSheet URL: http://www.hansa.com/datasheet/51180170/en; Type Name: 51180170 Wall coupling for shower hose, G1/2; Warranty Information URL: http://warranty.hansa.com
Type - Materials and Finishes - FaucetMainMaterial: Chrome
Type - Mechanical - Additional Features: protected against back-flow in domestic use (according to DIN EN 1717); Backflow Prevention EN1717: EB; Concealed Parts: Square rosette; Connection: Direct connection; Connection Size: G1/2; Installation Type: Wall mounted; Max. Hot Water Supply: 80 kg/K/s3; Mechanical Parts: Non-return valve(s); Shower Parts: Wall connection elbow; Surface treatment: Chrome; Working Pressure: 50 - 1000 kPa
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: HANSA; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 51180170; Features: n/a; Finish: Polished; Grade: n/a; ModelNumber: n/a; ModelReference: 51180170; Name: 51180170 Wall coupling for shower hose, G1/2; ReplacementCost: n/a; Shape: Sculptured; Size: 75x213x175 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.hansa.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Pset_ValveTypeCommon - ValvePattern: n/a; ValveOperation: n/a; ValveMechanism: n/a; FlowCoefficient: 0; CloseOffRating: 0 Pa
Type - Pset_ValveTypeFaucet - Finish: Polished
Pset_DistributionFlowElementCommon - Reference: 51180170 Wall coupling for shower hose, G1/2; sets with these values: 2
Pset_ElementShading - Color: Chrome
Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Pset_ManufacturerTypeInformation - ModelReference: 51180170; Manufacturer: HANSA
Pset_ProductRequirements - Name: 51180170 Wall coupling for shower hose, G1/2; Category: Plumbing Fixtures
Constraints - DefaultElevation: 900 mm; Elevation from Level: 0 mm; Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset from Host: 0 mm
Dimensions - Area: 0.014625 m2; Volume: 0.0003375 m3
Identity Data - Mark: 2
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 51180170: 51180170 Wall coupling for shower hose, G1/2; Family and Type: 51180170: 51180170 Wall coupling for shower hose, G1/2; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 51180170: 51180170 Wall coupling for shower hose, G1/2; Type Id: 51180170: 51180170 Wall coupling for shower hose, G1/2; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
